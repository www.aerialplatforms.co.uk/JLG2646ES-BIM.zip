Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T19:43:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 19:43:08 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{E6C734D6-94CB-4B81-A788-D95C5441741B}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 19:43:00 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 19:43:01 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 19:43:01 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: 1001180000_2646ES, 1001180000_2646ES:1001180000_2646ES:898140
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Paint_Orange, JLG_Paint_Black, JLG_Plastic_Red, JLG_Paint_White, JLG_Metal Paint_Black, JLG_Steel, JLG_Rubber_Light Grey, JLG_Metal Paint_White, JLG_Paint_Beige, JLG_Plastic_Yellow
Type - Constraints - Height: -763 mm; Ht: 494 mm; Offset: 1257 mm; Platform_Height: 0 mm; Platform Extension: 0 mm; Platform Extension Maximum: User to define Extension; Platform Height Maximum: User to define Height; Platform Length: 2500 mm; PS: 2500 mm; PX: 0 mm; Static: 763 mm; Transportation Condition: no
Type - Data - Deep Cycle Batteries: 4 x 6v 220 Ah; Drive: 24v Electric 6 kW; Drive Speed Elevated: 1 kph (0.61 mph); Drive Speed lowered: 4 kph (2.48 mph); Gradeability: 25%; Gross Vehicle Weight (ANSI): 2302 kg (5075 lbs); Gross Vehicle Weight (CE): 2783 kg (6135 lbs); Ground Clearance: 0.13 m (0 ft 5 in); Hydraulic system: 20 L (4.40 gal); Lift Up time: 40 sec; Lower down Time: 50 sec; Max Ground Bearing Pressure (ANSI): 6.98kg/cm2 (99.27 psi); Max Ground Bearing Pressure (CE): 6.98 kg/cm2 (99.27 psi); Platform Capacity (ANSI): 454kg (1000 lbs); Platform Capacity (CE): 450kg (992 lbs); Platform Extension Size: 1.22 m (4 ft 0 in); Platform Extention Capacity (ANSI): 113kg (250 lbs); Platform Extention Capacity (CE): 120kg (264 lbs); Platform Height: 7.96 m (26 ft 1 in); Platform Size: 1.12 m x 2.50 m (3 ft 8 in x 8 ft 2.5 in); Turning Radius Inside: 0; Turning Radius Outside: 2.41 m (7 ft 11 in); Tyres: 406 x 125mm Solid Non Marking
Type - General - Electric Scissor Lift: JLG_2646ES; Platform Extension Size ( L): 1.22 m (4 ft 0 in); Platform Size (W x L): 1.12 m x 2.50 m (3 ft 8 in x 8 ft 2.5 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: 1001180000_2646ES; URL: www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001180000 _2646ES; NBSDescription: Scissor Lift; NBSNote: n/a; NBSObjectName: JLG 2646ES_Scissor Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001180000_2646ES; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 2646ES; ModelReference: JLG - Scissor Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - BWA: no; Extension Working Area: no; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Turning Radius: no; Working Area: no
Dimensions - Area: 106.324 m2; Volume: 0.413513 m3
Identity Data - Mark: 38
Other - Family: 1001180000_2646ES: 1001180000_2646ES; Family and Type: 1001180000_2646ES: 1001180000_2646ES; Type: 1001180000_2646ES: 1001180000_2646ES; Type Id: 1001180000_2646ES: 1001180000_2646ES; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
